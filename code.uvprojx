# Keil uVision project code.uvprojx, settings and files
target code (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\c_lagLib;.\sensor;.\BaseConfig
  asm include: ..\c_lagLib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./: main.c
  group sensor
    ./sensor/: co2.c pm25.c tem.c
  group BaseConfig
    ./BaseConfig/: base_config.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
